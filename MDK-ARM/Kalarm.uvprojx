# Keil uVision project Kalarm.uvprojx, settings and files
target Kalarm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Kalarm
  AfterMake: fromelf --bin --output  .\Kalarm\Kalarm.bin  .\Kalarm\Kalarm.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\Src\uart_api;..\Src\mqtt_lib;..\Src\common;..\Src\flash;..\Src\mqtt_hw;..\Src\mqtt_api;..\Src\lan_api;..\Src\rtc_timer;..\Src\radio;..\Src\RTT;..\Src\key_value;..\Src\transplant;..\Src\aes;..\Src\crc;..\Src\cmdFramework;..\Src\upgrade
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8005800 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c croutine.c event_groups.c queue.c list.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_rtc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: freertos.c usart.c stm32f1xx_it.c gpio.c stm32f1xx_hal_msp.c dma.c rtc.c main.c tim.c spi.c
  group mqtt_lib
    ../Src/mqtt_lib/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group mqtt_api
    ../Src/common/: slist.c
    ../Src/mqtt_api/: mqtt_app.c
  group mqtt_hw
    ../Src/mqtt_hw/: transport.c
  group lan_api
    ../Src/lan_api/: lan.c lan_app.c
  group uart_api
    ../Src/uart_api/: uart_driver.c
  group common
    ../Src/common/: common.c cycle_queue.c snlist.c
  group flash
    ../Src/flash/: insideflash.c spi_flash.c spi_flash_app.c
  group key_value
    ../Src/key_value/: key_value.c
  group transplant
    ../Src/transplant/: transplant.c
  group upgrade
    ../Src/upgrade/: upgrade.c
  group crc
    ../Src/crc/: crc.c
  group aes
    ../Src/aes/: aes.c encrypt.c
  group cmd
    ../Src/cmdFramework/: commandprocessing.c
software components: CMSIS:CORE 4.3.0
